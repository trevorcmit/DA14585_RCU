# Keil uVision project secondary_bootloader.uvprojx, settings and files
target secondary_bootloader (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: secondary_bootloader +hex
  AfterMake: fromelf --bincombined --output=".\Out\@L.bin"  "!L"
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c misc: --c99
  c include: .\includes;..\..\sdk\platform\include;..\..\sdk\platform\driver\spi;..\..\sdk\platform\driver\i2c_core;..\..\sdk\platform\driver\i2c_eeprom;..\..\sdk\platform\driver\spi_flash;..\..\sdk\platform\driver\gpio;..\..\sdk\platform\arch;..\..\sdk\platform\arch\compiler\rvds;..\..\sdk\platform\arch\ll\rvds;..\..\sdk\platform\driver\reg
  asm include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\bootloader.sct
  group boot
    ./startup/: startup_CMSDK_CM0.s system_CMSDK.c
  group src
    ./src/: bootloader.c timer.c uart.c main.c uart_booter.c spi_commands.c crc32.c sw_aes.c decrypt.c
    ../../sdk/platform/driver/spi_flash/: spi_flash.c
    ../../sdk/platform/driver/spi/: spi.c
    ../../sdk/platform/driver/gpio/: gpio.c
    ../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
  group includes
    ./includes/: user_periph_setup.h timer.h uart.h uart_booter.h bootloader.h spi_commands.h os_int.h os_port.h sw_aes.h
    ../../sdk/platform/include/: datasheet.h
    ../../sdk/platform/driver/spi/: spi.h
    ../../sdk/platform/driver/spi_flash/: spi_flash.h
    ../../sdk/platform/driver/gpio/: gpio.h
    ../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
