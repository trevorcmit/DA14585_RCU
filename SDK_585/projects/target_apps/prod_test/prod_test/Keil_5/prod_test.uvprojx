# Keil uVision project prod_test.uvprojx, settings and files
target prod_test_585 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: prod_test_585 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused.txt"
  c include: .\..\..\..\..\..\sdk\platform\include;.\..\..\..\..\..\sdk\app_modules\api;.\..\..\..\..\..\sdk\app_modules\src\app_bass;.\..\..\..\..\..\sdk\app_modules\src\app_diss;.\..\..\..\..\..\sdk\app_modules\src\app_proxr;.\..\..\..\..\..\sdk\app_modules\src\app_spotar;.\..\..\..\..\..\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk\ble_stack\hcic;.\..\..\..\..\..\sdk\ble_stack\hcih;.\..\..\..\..\..\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk\ble_stack\profiles;.\..\..\..\..\..\sdk\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxr\api;.\..\..\..\..\..\sdk\ble_stack\profiles\spota\spotar;.\..\..\..\..\..\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk\ble_stack\ea\api;.\..\..\..\..\..\sdk\ble_stack\em\api;.\..\..\..\..\..\sdk\common_project_files;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\arch\boot\rvds;.\..\..\..\..\..\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\sdk\platform\arch\ll\rvds;.\..\..\..\..\..\sdk\platform\arch\main;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk\platform\core_modules\crypto;.\..\..\..\..\..\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk\platform\core_modules\wlan_coex;.\..\..\..\..\..\sdk\platform\driver\adc;.\..\..\..\..\..\sdk\platform\driver\battery;.\..\..\..\..\..\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\sdk\platform\driver\reg;.\..\..\..\..\..\sdk\platform\driver\spi;.\..\..\..\..\..\sdk\platform\driver\spi_flash;.\..\..\..\..\..\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk\platform\driver\systick;.\..\..\..\..\..\sdk\platform\driver\trng;.\..\..\..\..\..\sdk\platform\driver\uart;.\..\..\..\..\..\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\sdk\platform\driver\ble;.\..\..\..\..\..\sdk\platform\driver\emi;.\..\..\..\..\..\sdk\platform\driver\intc;.\..\..\..\..\..\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\sdk\platform\driver\dma;.\..\..\..\..\..\sdk\platform\driver\pdm;.\..\src\config;.\..\src;..\..\..\..\..\sdk\platform\system_library\include;.\..\..\..\..\..\sdk\ble_stack\hci\src;.\..\..\..\..\..\sdk\ble_stack\hci\api;.\..\..\..\..\..\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\;..\..\..\..\..\projects\target_apps\prod_test\prod_test\src\system
  library: MicroLIB
  scatter file: .\..\..\..\..\..\sdk\common_project_files\scatterfiles\scatterfile_common.sct
  link misc: --feedback=".\unused.txt" .\..\..\..\..\..\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=hci_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    ./../../../../../sdk/platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    ./../../../../../sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ./../../../../../sdk/platform/core_modules/arch_console/: arch_console.c
    ./../../../../../sdk/platform/core_modules/nvds/src/: nvds.c
    ./../../../../../sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c
    ../../../../../sdk/platform/arch/main/: arch_rom.c
    ../../../../../sdk/platform/system_library/output/Keil_5/: system_library.lib
  group sdk_driver
    ./../../../../../sdk/platform/driver/syscntl/: syscntl.c
    ./../../../../../sdk/platform/driver/gpio/: gpio.c
    ./../../../../../sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    ./../../../../../sdk/platform/driver/battery/: battery.c
    ./../../../../../sdk/platform/driver/adc/: adc.c
    ./../../../../../sdk/platform/driver/spi_flash/: spi_flash.c
    ./../../../../../sdk/platform/driver/spi/: spi.c
    ../../../../../sdk/platform/driver/hw_otpc/: hw_otpc.c
    ../../../../../sdk/platform/driver/trng/: trng.c
  group sdk_ble
    ../../../../../sdk/platform/core_modules/rf/src/: rf_585.c
    ./../../../../../sdk/ble_stack/rwble/: rwble.c
    ./../../../../../sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    ../../../../../sdk/ble_stack/profiles/: prf.c
  group sdk_driver_api
    ../../../../../sdk/platform/driver/adc/: adc.h
    ../../../../../sdk/platform/driver/battery/: battery.h
    ../../../../../sdk/platform/driver/gpio/: gpio.h
    ../../../../../sdk/platform/driver/spi/: spi.h
    ../../../../../sdk/platform/driver/spi_flash/: spi_flash.h
    ../../../../../sdk/platform/driver/systick/: systick.h
    ../../../../../sdk/platform/driver/trng/: trng.h
    ../../../../../sdk/platform/driver/uart/: uart.h
    ../../../../../sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_arch_api
    ../../../../../sdk/platform/arch/: arch_api.h
    ../../../../../sdk/platform/arch/main/: arch_wdg.h
    ../../../../../sdk/platform/core_modules/arch_console/: arch_console.h
  group user_config
    ../src/config/: da1458x_config_basic.h da1458x_config_advanced.h user_callback_config.h user_periph_setup.h user_config_sw_ver.h
  group user_platform
    ../src/platform/: user_periph_setup.c
  group vs_hci
    ../src/: hci_vs.c dialog_commands.c user_commands.c
  group app
    ../src/: dialog_prod.c xtal_cal.c pulse.s rdtest_api.c rdtest_lowlevel.c rdtest_support.c
    ../src/system/: mainloop_callbacks.c
target prod_test_586 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: prod_test_586 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: as above
  c include: .\..\..\..\..\..\sdk\platform\include;.\..\..\..\..\..\sdk\app_modules\api;.\..\..\..\..\..\sdk\app_modules\src\app_bass;.\..\..\..\..\..\sdk\app_modules\src\app_diss;.\..\..\..\..\..\sdk\app_modules\src\app_proxr;.\..\..\..\..\..\sdk\app_modules\src\app_spotar;.\..\..\..\..\..\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk\ble_stack\hcic;.\..\..\..\..\..\sdk\ble_stack\hcih;.\..\..\..\..\..\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk\ble_stack\profiles;.\..\..\..\..\..\sdk\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxr\api;.\..\..\..\..\..\sdk\ble_stack\profiles\spota\spotar;.\..\..\..\..\..\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk\ble_stack\ea\api;.\..\..\..\..\..\sdk\ble_stack\em\api;.\..\..\..\..\..\sdk\common_project_files;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\arch\boot\rvds;.\..\..\..\..\..\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\sdk\platform\arch\ll\rvds;.\..\..\..\..\..\sdk\platform\arch\main;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk\platform\core_modules\crypto;.\..\..\..\..\..\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk\platform\core_modules\wlan_coex;.\..\..\..\..\..\sdk\platform\driver\adc;.\..\..\..\..\..\sdk\platform\driver\battery;.\..\..\..\..\..\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\sdk\platform\driver\reg;.\..\..\..\..\..\sdk\platform\driver\spi;.\..\..\..\..\..\sdk\platform\driver\spi_flash;.\..\..\..\..\..\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk\platform\driver\systick;.\..\..\..\..\..\sdk\platform\driver\trng;.\..\..\..\..\..\sdk\platform\driver\uart;.\..\..\..\..\..\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\sdk\platform\driver\ble;.\..\..\..\..\..\sdk\platform\driver\emi;.\..\..\..\..\..\sdk\platform\driver\intc;.\..\..\..\..\..\sdk\platform\driver\hw_otpc;.\..\src\config;.\..\src;..\..\..\..\..\sdk\platform\system_library\include;.\..\..\..\..\..\sdk\ble_stack\hci\src;.\..\..\..\..\..\sdk\ble_stack\hci\api;.\..\..\..\..\..\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\;..\..\..\..\..\projects\target_apps\prod_test\prod_test\src\system
  library: MicroLIB
  scatter file: as above
  link misc: --feedback=".\unused.txt" .\..\..\..\..\..\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=hci_586_symdef.txt --any_placement=best_fit --datacompressor off
