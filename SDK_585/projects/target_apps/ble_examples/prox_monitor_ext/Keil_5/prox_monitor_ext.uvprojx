# Keil uVision project prox_monitor_ext.uvprojx, settings and files
target prox_monitor_ext_585 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: prox_monitor_ext_585 +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h  --preinclude user_config.h --bss_threshold=0 --feedback=".\unused.txt"
  c include: .\..\;.\..\..\..\..\..\sdk\platform\include;.\..\..\..\..\..\sdk\app_modules\api;.\..\..\..\..\..\sdk\app_modules\src\app_bass;.\..\..\..\..\..\sdk\app_modules\src\app_custs;.\..\..\..\..\..\sdk\app_modules\src\app_diss;.\..\..\..\..\..\sdk\app_modules\src\app_findme;.\..\..\..\..\..\sdk\app_modules\src\app_multi_bond;.\..\..\..\..\..\sdk\app_modules\src\app_proxr;.\..\..\..\..\..\sdk\app_modules\src\app_suotar;.\..\..\..\..\..\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk\common_project_files;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\arch\boot\rvds;.\..\..\..\..\..\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\sdk\platform\arch\ll\rvds;.\..\..\..\..\..\sdk\platform\arch\main;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk\platform\core_modules\crypto;.\..\..\..\..\..\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk\platform\core_modules\wlan_coex;.\..\..\..\..\..\sdk\platform\driver\adc;.\..\..\..\..\..\sdk\platform\driver\battery;.\..\..\..\..\..\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\sdk\platform\driver\pwm;.\..\..\..\..\..\sdk\platform\driver\reg;.\..\..\..\..\..\sdk\platform\driver\spi;.\..\..\..\..\..\sdk\platform\driver\spi_flash;.\..\..\..\..\..\sdk\platform\driver\spi_hci;.\..\..\..\..\..\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk\platform\driver\systick;.\..\..\..\..\..\sdk\platform\driver\trng;.\..\..\..\..\..\sdk\platform\driver\uart;.\..\..\..\..\..\sdk\platform\driver\wkupct_quadec;.\..\src\config;.\..\src;.\..\..\..\..\..\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\sdk\platform\core_modules\h4tl\api;./../../../../../sdk/ble_stack/profiles/anp;./../../../../../sdk/ble_stack/profiles/anp/anpc/api;./../../../../../sdk/ble_stack/profiles/anp/anps/api;./../../../../../sdk/ble_stack/profiles/bas/basc/api;./../../../../../sdk/ble_stack/profiles/bas/bass/api;./../../../../../sdk/ble_stack/profiles/blp;./../../../../../sdk/ble_stack/profiles/blp/blpc/api;./../../../../../sdk/ble_stack/profiles/blp/blps/api;./../../../../../sdk/ble_stack/profiles/cpp;./../../../../../sdk/ble_stack/profiles/cpp/cppc/api;./../../../../../sdk/ble_stack/profiles/cpp/cpps/api;./../../../../../sdk/ble_stack/profiles/cscp;./../../../../../sdk/ble_stack/profiles/cscp/cscpc/api;./../../../../../sdk/ble_stack/profiles/cscp/cscps/api;./../../../../../sdk/ble_stack/profiles/find;./../../../../../sdk/ble_stack/profiles/dis/disc/api;./../../../../../sdk/ble_stack/profiles/dis/diss/api;./../../../../../sdk/ble_stack/profiles;./../../../../../sdk/ble_stack/profiles/find/findl/api;./../../../../../sdk/ble_stack/profiles/find/findt/api;./../../../../../sdk/ble_stack/profiles/glp;./../../../../../sdk/ble_stack/profiles/glp/glpc/api;./../../../../../sdk/ble_stack/profiles/glp/glps/api;./../../../../../sdk/ble_stack/profiles/hogp;./../../../../../sdk/ble_stack/profiles/hogp/hogpbh/api;./../../../../../sdk/ble_stack/profiles/hogp/hogpd/api;./../../../../../sdk/ble_stack/profiles/hogp/hogprh/api;./../../../../../sdk/ble_stack/profiles/hrp;./../../../../../sdk/ble_stack/profiles/hrp/hrpc/api;./../../../../../sdk/ble_stack/profiles/hrp/hrps/api;./../../../../../sdk/ble_stack/profiles/htp;./../../../../../sdk/ble_stack/profiles/htp/htpc/api;./../../../../../sdk/ble_stack/profiles/htp/htpt/api;./../../../../../sdk/ble_stack/profiles/lan;./../../../../../sdk/ble_stack/profiles/lan/lanc/api;./../../../../../sdk/ble_stack/profiles/lan/lans/api;./../../../../../sdk/ble_stack/profiles/pasp;./../../../../../sdk/ble_stack/profiles/pasp/paspc/api;./../../../../../sdk/ble_stack/profiles/pasp/pasps/api;./../../../../../sdk/ble_stack/profiles/prox/proxm/api;./../../../../../sdk/ble_stack/profiles/prox/proxr/api;./../../../../../sdk/ble_stack/profiles/rscp;./../../../../../sdk/ble_stack/profiles/rscp/rscpc/api;./../../../../../sdk/ble_stack/profiles/rscp/rscps/api;./../../../../../sdk/ble_stack/profiles/scpp;./../../../../../sdk/ble_stack/profiles/scpp/scppc/api;./../../../../../sdk/ble_stack/profiles/scpp/scpps/api;./../../../../../sdk/ble_stack/profiles/tip;./../../../../../sdk/ble_stack/profiles/tip/tipc/api;./../../../../../sdk/ble_stack/profiles/tip/tips/api;..\..\..\..\..\sdk\ble_stack\em\api;..\..\..\..\..\sdk\platform\driver\ble;..\..\..\..\..\sdk\ble_stack\ea\api;..\..\..\..\..\sdk\ble_stack\hci\api;..\..\..\..\..\sdk\platform\driver\hw_otpc;..\..\..\..\..\sdk\platform\system_library\include;.\..\..\..\..\..\sdk\platform\driver\dma;.\..\..\..\..\..\sdk\platform\driver\pdm
  library: MicroLIB
  scatter file: .\..\..\..\..\..\sdk\common_project_files\scatterfiles\scatterfile_common.sct
  link misc: --feedback=".\unused.txt" .\..\..\..\..\..\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=prox_monitor_ext_585_symdef.txt --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
  group sdk_boot
    ./../../../../../sdk/platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    ./../../../../../sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ./../../../../../sdk/platform/core_modules/arch_console/: arch_console.c
    ./../../../../../sdk/platform/core_modules/nvds/src/: nvds.c
    ./../../../../../sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c
    ../../../../../sdk/platform/arch/main/: arch_rom.c
    ../../../../../sdk/platform/system_library/output/Keil_5/: system_library.lib
  group sdk_driver
    ./../../../../../sdk/platform/driver/syscntl/: syscntl.c
    ./../../../../../sdk/platform/driver/gpio/: gpio.c
    ./../../../../../sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    ./../../../../../sdk/platform/driver/battery/: battery.c
    ./../../../../../sdk/platform/driver/adc/: adc.c
    ../../../../../sdk/platform/driver/spi/: spi.c
    ../../../../../sdk/platform/driver/spi_flash/: spi_flash.c
    ../../../../../sdk/platform/driver/hw_otpc/: hw_otpc.c
    ../../../../../sdk/platform/driver/trng/: trng.c
    ../../../../../sdk/platform/driver/uart/: uart2.c
  group sdk_ble
    ../../../../../sdk/platform/core_modules/rf/src/: rf_585.c
    ./../../../../../sdk/ble_stack/rwble/: rwble.c
    ./../../../../../sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    ./../../../../../sdk/ble_stack/profiles/dis/disc/src/: disc.c disc_task.c
    ./../../../../../sdk/ble_stack/profiles/prox/proxm/src/: proxm.c proxm_task.c
    ../../../../../sdk/ble_stack/profiles/: prf.c
    ./../../../../../sdk/ble_stack/profiles/: prf_utils.c
  group sdk_driver_api
    ../../../../../sdk/platform/driver/adc/: adc.h
    ../../../../../sdk/platform/driver/battery/: battery.h
    ../../../../../sdk/platform/driver/gpio/: gpio.h
    ../../../../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    ../../../../../sdk/platform/driver/spi/: spi.h
    ../../../../../sdk/platform/driver/spi_flash/: spi_flash.h
    ../../../../../sdk/platform/driver/systick/: systick.h
    ../../../../../sdk/platform/driver/trng/: trng.h
    ../../../../../sdk/platform/driver/uart/: uart.h
    ../../../../../sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_arch_api
    ../../../../../sdk/platform/arch/: arch_api.h
    ../../../../../sdk/platform/arch/main/: arch_wdg.h
    ../../../../../sdk/platform/core_modules/arch_console/: arch_console.h
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_periph_setup.h user_profiles_config.h
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_proxm.c
target prox_monitor_ext_586 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: prox_monitor_ext_586 +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DA14586__
  c misc: as above
  c include: .\..\;.\..\..\..\..\..\sdk\platform\include;.\..\..\..\..\..\sdk\app_modules\api;.\..\..\..\..\..\sdk\app_modules\src\app_bass;.\..\..\..\..\..\sdk\app_modules\src\app_custs;.\..\..\..\..\..\sdk\app_modules\src\app_diss;.\..\..\..\..\..\sdk\app_modules\src\app_findme;.\..\..\..\..\..\sdk\app_modules\src\app_multi_bond;.\..\..\..\..\..\sdk\app_modules\src\app_proxr;.\..\..\..\..\..\sdk\app_modules\src\app_suotar;.\..\..\..\..\..\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk\common_project_files;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\arch\boot\rvds;.\..\..\..\..\..\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\sdk\platform\arch\ll\rvds;.\..\..\..\..\..\sdk\platform\arch\main;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk\platform\core_modules\crypto;.\..\..\..\..\..\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk\platform\core_modules\wlan_coex;.\..\..\..\..\..\sdk\platform\driver\adc;.\..\..\..\..\..\sdk\platform\driver\battery;.\..\..\..\..\..\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\sdk\platform\driver\pwm;.\..\..\..\..\..\sdk\platform\driver\reg;.\..\..\..\..\..\sdk\platform\driver\spi;.\..\..\..\..\..\sdk\platform\driver\spi_flash;.\..\..\..\..\..\sdk\platform\driver\spi_hci;.\..\..\..\..\..\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk\platform\driver\systick;.\..\..\..\..\..\sdk\platform\driver\trng;.\..\..\..\..\..\sdk\platform\driver\uart;.\..\..\..\..\..\sdk\platform\driver\wkupct_quadec;.\..\src\config;.\..\src;.\..\..\..\..\..\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\sdk\platform\core_modules\h4tl\api;./../../../../../sdk/ble_stack/profiles/anp;./../../../../../sdk/ble_stack/profiles/anp/anpc/api;./../../../../../sdk/ble_stack/profiles/anp/anps/api;./../../../../../sdk/ble_stack/profiles/bas/basc/api;./../../../../../sdk/ble_stack/profiles/bas/bass/api;./../../../../../sdk/ble_stack/profiles/blp;./../../../../../sdk/ble_stack/profiles/blp/blpc/api;./../../../../../sdk/ble_stack/profiles/blp/blps/api;./../../../../../sdk/ble_stack/profiles/cpp;./../../../../../sdk/ble_stack/profiles/cpp/cppc/api;./../../../../../sdk/ble_stack/profiles/cpp/cpps/api;./../../../../../sdk/ble_stack/profiles/cscp;./../../../../../sdk/ble_stack/profiles/cscp/cscpc/api;./../../../../../sdk/ble_stack/profiles/cscp/cscps/api;./../../../../../sdk/ble_stack/profiles/find;./../../../../../sdk/ble_stack/profiles/dis/disc/api;./../../../../../sdk/ble_stack/profiles/dis/diss/api;./../../../../../sdk/ble_stack/profiles;./../../../../../sdk/ble_stack/profiles/find/findl/api;./../../../../../sdk/ble_stack/profiles/find/findt/api;./../../../../../sdk/ble_stack/profiles/glp;./../../../../../sdk/ble_stack/profiles/glp/glpc/api;./../../../../../sdk/ble_stack/profiles/glp/glps/api;./../../../../../sdk/ble_stack/profiles/hogp;./../../../../../sdk/ble_stack/profiles/hogp/hogpbh/api;./../../../../../sdk/ble_stack/profiles/hogp/hogpd/api;./../../../../../sdk/ble_stack/profiles/hogp/hogprh/api;./../../../../../sdk/ble_stack/profiles/hrp;./../../../../../sdk/ble_stack/profiles/hrp/hrpc/api;./../../../../../sdk/ble_stack/profiles/hrp/hrps/api;./../../../../../sdk/ble_stack/profiles/htp;./../../../../../sdk/ble_stack/profiles/htp/htpc/api;./../../../../../sdk/ble_stack/profiles/htp/htpt/api;./../../../../../sdk/ble_stack/profiles/lan;./../../../../../sdk/ble_stack/profiles/lan/lanc/api;./../../../../../sdk/ble_stack/profiles/lan/lans/api;./../../../../../sdk/ble_stack/profiles/pasp;./../../../../../sdk/ble_stack/profiles/pasp/paspc/api;./../../../../../sdk/ble_stack/profiles/pasp/pasps/api;./../../../../../sdk/ble_stack/profiles/prox/proxm/api;./../../../../../sdk/ble_stack/profiles/prox/proxr/api;./../../../../../sdk/ble_stack/profiles/rscp;./../../../../../sdk/ble_stack/profiles/rscp/rscpc/api;./../../../../../sdk/ble_stack/profiles/rscp/rscps/api;./../../../../../sdk/ble_stack/profiles/scpp;./../../../../../sdk/ble_stack/profiles/scpp/scppc/api;./../../../../../sdk/ble_stack/profiles/scpp/scpps/api;./../../../../../sdk/ble_stack/profiles/tip;./../../../../../sdk/ble_stack/profiles/tip/tipc/api;./../../../../../sdk/ble_stack/profiles/tip/tips/api;..\..\..\..\..\sdk\ble_stack\em\api;..\..\..\..\..\sdk\platform\driver\ble;..\..\..\..\..\sdk\ble_stack\ea\api;..\..\..\..\..\sdk\ble_stack\hci\api;..\..\..\..\..\sdk\platform\driver\hw_otpc;..\..\..\..\..\sdk\platform\system_library\include
  library: MicroLIB
  scatter file: as above
  link misc: --feedback=".\unused.txt" .\..\..\..\..\..\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=prox_monitor_ext_586_symdef.txt --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
