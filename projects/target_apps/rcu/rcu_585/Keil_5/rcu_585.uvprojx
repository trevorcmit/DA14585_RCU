# Keil uVision project rcu_585.uvprojx, settings and files
target rcu_585_refdes (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: rcu_585 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --feedback "out_585\rcu_585.fed" --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0
  c include: .\..\;.\..\..\..\..\..\SDK_585\sdk\platform\include;C:\Keil\ARM\RV31\INC;c:\Keil\ARM\CMSIS\Include;.\..\..\..\..\..\SDK_585\sdk\app_modules\api;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_bass;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_custs;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_diss;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_findme;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_multi_bond;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_proxr;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_suotar;.\..\..\..\..\..\SDK_585\sdk\ble_stack\controller\em;.\..\..\..\..\..\SDK_585\sdk\ble_stack\controller\llc;.\..\..\..\..\..\SDK_585\sdk\ble_stack\controller\lld;.\..\..\..\..\..\SDK_585\sdk\ble_stack\controller\llm;.\..\..\..\..\..\SDK_585\sdk\ble_stack\ea\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\em\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\hci\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\hcic;.\..\..\..\..\..\SDK_585\sdk\ble_stack\hcih;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\att;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\gap;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\gatt;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\smp;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\device_config;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\hogp\hogpd\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\custom\custs\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\streamdata\streamdatad;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\streamdata\streamdatah;.\..\..\..\..\..\SDK_585\sdk\ble_stack\rwble;.\..\..\..\..\..\SDK_585\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\SDK_585\sdk\common_project_files;.\..\..\..\..\..\SDK_585\sdk\platform\arch;.\..\..\..\..\..\SDK_585\sdk\platform\arch\boot\rvds;.\..\..\..\..\..\SDK_585\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\SDK_585\sdk\platform\arch\ll\rvds;.\..\..\..\..\..\SDK_585\sdk\platform\arch\main;.\..\..\..\..\..\SDK_585\sdk\platform\arch;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\common\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\crypto;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\wlan_coex;.\..\..\..\..\..\SDK_585\sdk\platform\driver\accel;.\..\..\..\..\..\SDK_585\sdk\platform\driver\adc;.\..\..\..\..\..\SDK_585\sdk\platform\driver\battery;.\..\..\..\..\..\SDK_585\sdk\platform\driver\ble;.\..\..\..\..\..\SDK_585\sdk\platform\driver\bme280;.\..\..\..\..\..\SDK_585\sdk\platform\driver\coex;.\..\..\..\..\..\SDK_585\sdk\platform\driver\coex;.\..\..\..\..\..\SDK_585\sdk\platform\driver\dma;.\..\..\..\..\..\SDK_585\sdk\platform\driver\emi;.\..\..\..\..\..\SDK_585\sdk\platform\driver\gpio;.\..\..\..\..\..\SDK_585\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\SDK_585\sdk\platform\driver\i2c_core;.\..\..\..\..\..\SDK_585\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\SDK_585\sdk\platform\driver\intc;.\..\..\..\..\..\SDK_585\sdk\platform\driver\inv;.\..\..\..\..\..\SDK_585\sdk\platform\driver\led;.\..\..\..\..\..\SDK_585\sdk\platform\driver\mc3410;.\..\..\..\..\..\SDK_585\sdk\platform\driver\pdm;.\..\..\..\..\..\SDK_585\sdk\platform\driver\timer;.\..\..\..\..\..\SDK_585\sdk\platform\driver\rc5;.\..\..\..\..\..\SDK_585\sdk\platform\driver\reg;.\..\..\..\..\..\SDK_585\sdk\platform\driver\sensor;.\..\..\..\..\..\SDK_585\sdk\platform\driver\spi;.\..\..\..\..\..\SDK_585\sdk\platform\driver\spi_439;.\..\..\..\..\..\SDK_585\sdk\platform\driver\spi_flash;.\..\..\..\..\..\SDK_585\sdk\platform\driver\spi_hci;.\..\..\..\..\..\SDK_585\sdk\platform\driver\syscntl;.\..\..\..\..\..\SDK_585\sdk\platform\driver\systick;.\..\..\..\..\..\SDK_585\sdk\platform\driver\trng;.\..\..\..\..\..\SDK_585\sdk\platform\driver\uart;.\..\..\..\..\..\SDK_585\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\SDK_585\sdk\platform\system_library\include;..\..\..\..\..\modules_library\app_audio;..\..\..\..\..\modules_library\app_buzzer;..\..\..\..\..\modules_library\app_con_fsm;..\..\..\..\..\modules_library\app_dbg;..\..\..\..\..\modules_library\app_flash;..\..\..\..\..\modules_library\app_kbd;..\..\..\..\..\modules_library\app_gpio_keys;..\..\..\..\..\modules_library\app_hid_report;..\..\..\..\..\modules_library\app_leds;..\..\..\..\..\modules_library\app_motion;..\..\..\..\..\modules_library\app_mouse;..\..\..\..\..\modules_library\app_nv_prom;..\..\..\..\..\modules_library\app_ir;..\..\..\..\..\modules_library\app_stream;..\..\..\..\..\modules_library\app_touch;..\..\..\..\..\modules_library\app_touchpad;..\..\..\..\..\modules_library\port_58x;..\..\..\..\..\modules_library\port_58x\con_fsm;..\..\..\..\..\modules_library\port_58x\port_585\audio;..\src\profiles\dlg_audio_svc;..\src\profiles\hogpd;..\src\drivers;.\..\src;.\..\src\config;..\..\src;..\..\src\drivers\BMI160_driver;..\..\src\drivers\IQS263_driver;..\..\src\drivers\AzoteqIQS572_driver;..\..\src\drivers;..\..\src\platform
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\SDK_585\sdk\common_project_files\scatterfiles\scatterfile_common.sct
  link misc: --feedback "out_585\rcu_585.fed"  .\..\..\..\..\..\SDK_585\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=rcu_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    ./../../../../../SDK_585/sdk/platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    ./../../../../../SDK_585/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ./../../../../../SDK_585/sdk/platform/core_modules/arch_console/: arch_console.c
    ./../../../../../SDK_585/sdk/platform/core_modules/nvds/src/: nvds.c
    ./../../../../../SDK_585/sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c
    ../../../../../SDK_585/sdk/platform/arch/main/: arch_rom.c
    ../../../../../SDK_585/sdk/platform/system_library/output/Keil_5/: system_library.lib
  group sdk_driver
    ./../../../../../SDK_585/sdk/platform/driver/adc/: adc.c
    ./../../../../../SDK_585/sdk/platform/driver/battery/: battery.c
    ../../../../../SDK_585/sdk/platform/driver/dma/: dma.c
    ./../../../../../SDK_585/sdk/platform/driver/gpio/: gpio.c
    ../../../../../SDK_585/sdk/platform/driver/hw_otpc/: hw_otpc.c
    ../../../../../SDK_585/sdk/platform/driver/i2c_core/: i2c_core.c
    ../../../../../SDK_585/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ../../../../../SDK_585/sdk/platform/driver/pdm/: pdm.c pdm_mic.c
    ./../../../../../SDK_585/sdk/platform/driver/spi/: spi.c
    ./../../../../../SDK_585/sdk/platform/driver/spi_flash/: spi_flash.c
    ./../../../../../SDK_585/sdk/platform/driver/syscntl/: syscntl.c
    ./../../../../../SDK_585/sdk/platform/driver/systick/: systick.c
    ../../../../../SDK_585/sdk/platform/driver/timer/: timer0.c timer2.c
    ./../../../../../SDK_585/sdk/platform/driver/trng/: trng.c
    ./../../../../../SDK_585/sdk/platform/driver/uart/: uart2.c
    ./../../../../../SDK_585/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
  group sdk_ble
    ./../../../../../SDK_585/sdk/platform/core_modules/rf/src/: rf_585.c
    ./../../../../../SDK_585/sdk/ble_stack/rwble/: rwble.c
    ./../../../../../SDK_585/sdk/platform/core_modules/rwip/src/: rwip.c
    ../../../../../SDK_585/sdk/platform/core_modules/rf/src/: rf_ripple.c
  group sdk_profiles
    ../../../../../SDK_585/sdk/ble_stack/host/att/attm/: attm_db_128.c
    ./../../../../../SDK_585/sdk/ble_stack/profiles/bas/bass/src/: bass.c bass_task.c
    ../../../../../SDK_585/sdk/ble_stack/profiles/custom/: custom_common.c
    ../../../../../SDK_585/sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c
    ./../../../../../SDK_585/sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    ./../../../../../SDK_585/sdk/ble_stack/profiles/hogp/hogpd/src/: hogpd.c hogpd_task.c
    ./../../../../../SDK_585/sdk/ble_stack/profiles/: prf_utils.c
    ../../../../../SDK_585/sdk/ble_stack/profiles/: prf.c
    ../../../../../SDK_585/sdk/ble_stack/profiles/suota/suotar/src/: suotar.c suotar_task.c
  group sdk_app
    ./../../../../../SDK_585/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    ./../../../../../SDK_585/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c
    ./../../../../../SDK_585/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    ./../../../../../SDK_585/sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    ./../../../../../SDK_585/sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    ./../../../../../SDK_585/sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    ./../../../../../SDK_585/sdk/app_modules/src/app_entry/: app_entry_point.c
    ./../../../../../SDK_585/sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    ../../../../../SDK_585/sdk/app_modules/src/app_custs/: app_customs.c app_customs_common.c app_customs_task.c
  group sdk_driver_api
    ./../../../../../SDK_585/sdk/platform/driver/adc/: adc.h
    ./../../../../../SDK_585/sdk/platform/driver/battery/: battery.h
    ./../../../../../SDK_585/sdk/platform/driver/gpio/: gpio.h
    ./../../../../../SDK_585/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    ./../../../../../SDK_585/sdk/platform/driver/spi/: spi.h
    ./../../../../../SDK_585/sdk/platform/driver/spi_flash/: spi_flash.h
    ./../../../../../SDK_585/sdk/platform/driver/systick/: systick.h
    ../../../../../SDK_585/sdk/platform/driver/timer/: timer.h timer0.h timer2.h
    ./../../../../../SDK_585/sdk/platform/driver/trng/: trng.h
    ./../../../../../SDK_585/sdk/platform/driver/uart/: uart.h
    ./../../../../../SDK_585/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_app_api
    ./../../../../../SDK_585/sdk/app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_security.h app_easy_timer.h app_entry_point.h app_mid.h app_msg_utils.h app_security.h app_task.h app_user_config.h
  group sdk_arch_api
    ./../../../../../SDK_585/sdk/platform/arch/main/: arch_wdg.h
    ./../../../../../SDK_585/sdk/platform/arch/: arch_api.h
    ./../../../../../SDK_585/sdk/platform/core_modules/arch_console/: arch_console.h
  group user_config
    ./../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h
    ./: rcu.doxy
    ../src/config/: user_config_sw_ver.h user_custs1_def.h user_hogpd_config.h user_profiles_config.h user_pwr_mgr_config.h
  group user_config_ProDK
    ../src/config/variants/ProDK/: user_config.h user_periph_setup.h
  group user_app
    ../../src/: user_rcu.c user_rcu_audio.c user_rcu_kbd.c user_rcu_motion.c
  group user_platform
    ../../src/platform/: user_modules.c user_pwr_mgr.c user_periph_setup.c
  group user_drivers
    ../../src/drivers/IQS263_driver/: azotouch_iqs_263.c
    ../../src/drivers/AzoteqIQS572_driver/: azotouch_iqs5xx.c
    ../../src/drivers/BMI160_driver/: bmi160.c bmi160_support.c
    ../../src/drivers/: i2c_azotouch.c ir_driver.c
    ../src/drivers/: spi_3wire.c
  group user_profiles
    ../src/profiles/hogpd/: app_hogpd_task.c app_hogpd.c
    ../src/profiles/dlg_audio_svc/: user_custs_config.c user_dlg_audio_svc_def.c
  group app_modules
    ../../../../../modules_library/app_con_fsm/: app_adv_fsm.c app_con_fsm.c app_pairing.c app_white_list.c
    ../../../../../modules_library/app_audio/: app_audio.c app_audio_codec.c
    ../../../../../modules_library/app_buzzer/: app_buzzer.c
    ../../../../../modules_library/app_dbg/: app_dbg.c
    ../../../../../modules_library/app_flash/: app_flash.c
    ../../../../../modules_library/app_gpio_keys/: app_gpio_keys.c
    ../../../../../modules_library/app_hid_report/: app_hid_report.c
    ../../../../../modules_library/app_kbd/: app_kbd.c
    ../../../../../modules_library/app_leds/: app_leds.c
    ../../../../../modules_library/app_motion/: app_motion.c
    ../../../../../modules_library/app_mouse/: app_mouse.c
    ../../../../../modules_library/app_nv_prom/: app_nv_prom.c
    ../../../../../modules_library/app_ir/: app_ir.c
    ../../../../../modules_library/app_stream/: app_stream.c
    ../../../../../modules_library/app_touchpad/: app_touchpad.c
  group port_modules
    ../../../../../modules_library/port_58x/con_fsm/: port_adv_fsm.c port_con_fsm.c port_con_fsm_task.c port_multi_bond.c port_security.c port_white_list.c
    ../../../../../modules_library/port_58x/port_585/audio/: port_audio.c
    ../../../../../modules_library/port_58x/: port_buzzer.c port_gpio_keys.c port_ir.c port_kbd.c port_leds.c port_motion.c port_platform.c port_stream.c port_systick.c port_timer.c port_touchpad.c port_wkup.c
  group app_modules_api
    ../../../../../modules_library/app_con_fsm/: app_adv_fsm.h app_adv_fsm_defs.h app_con_fsm.h app_con_fsm_defs.h app_pairing.h
    ../../../../../modules_library/app_audio/: app_audio.h app_audio_codec.h
    ../../../../../modules_library/app_buzzer/: app_buzzer.h app_buzzer_defs.h
    ../../../../../modules_library/app_dbg/: app_dbg.h
    ../../../../../modules_library/app_flash/: app_flash.h
    ../../../../../modules_library/app_gpio_keys/: app_gpio_keys.h app_gpio_keys_defs.h
    ../../../../../modules_library/app_hid_report/: app_hid_report.h
    ../../../../../modules_library/app_kbd/: app_kbd.h app_kbd_defs.h
    ../../../../../modules_library/app_leds/: app_leds.h app_leds_defs.h
    ../../../../../modules_library/app_motion/: app_motion.h
    ../../../../../modules_library/app_mouse/: app_mouse.h
    ../../../../../modules_library/app_nv_prom/: app_nv_prom.h
    ../../../../../modules_library/app_ir/: app_ir.h app_ir_defs.h
    ../../../../../modules_library/app_stream/: app_stream.h
    ../../../../../modules_library/app_touchpad/: app_touchpad.h app_touchpad_defs.h
  group port_modules_api
    ../../../../../modules_library/port_58x/con_fsm/: port_adv_fsm.h port_con_fsm.h port_multi_bond.h port_security.h port_white_list.h
    ../../../../../modules_library/port_58x/port_585/audio/: port_audio.h
    ../../../../../modules_library/port_58x/: port_buzzer.h port_gpio_keys.h port_ir.h port_kbd.h port_leds.h port_motion.h port_platform.h port_stream.h port_systick.h port_timer.h port_touchpad.h port_wkup.h
  group modules_config
    ../src/config/: app_audio_config.h app_adv_fsm_config.h app_bmi160_config.h app_buzzer_config.h app_con_fsm_config.h app_flash_config.h app_gpio_keys_config.h app_hid_report_config.h app_ir_config.h app_kbd_config.h app_kbd_matrix.h app_kbd_scan_matrix.h app_leds_config.h app_motion_config.h app_mouse_config.h app_stream_config.h app_touchpad_config.h port_timer_config.h port_systick_config.h port_wkup_config.h
  group modules_config_ProDK
    ../src/config/variants/ProDK/: app_audio_config.h app_bmi160_config.h app_kbd_matrix.h app_kbd_scan_matrix.h app_motion_config.h
target rcu_585_ProDK (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: rcu_585_ProDK +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: HW_CONFIG_PRO_DK
  c misc: --feedback "out_585_ProDK\rcu_585_ProDK.fed" --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0
  c include: .\..\;C:\Keil\ARM\RV31\INC;c:\Keil\ARM\CMSIS\Include;.\..\..\..\..\..\SDK_585\sdk\app_modules\api;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_bass;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_custs;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_diss;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_findme;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_multi_bond;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_proxr;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_spotar;.\..\..\..\..\..\SDK_585\sdk\app_modules\src\app_suotar;.\..\..\..\..\..\SDK_585\sdk\ble_stack\controller\em;.\..\..\..\..\..\SDK_585\sdk\ble_stack\controller\llc;.\..\..\..\..\..\SDK_585\sdk\ble_stack\controller\lld;.\..\..\..\..\..\SDK_585\sdk\ble_stack\controller\llm;.\..\..\..\..\..\SDK_585\sdk\ble_stack\ea\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\em\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\hci\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\hcic;.\..\..\..\..\..\SDK_585\sdk\ble_stack\hcih;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\att;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\gap;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\gatt;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\SDK_585\sdk\ble_stack\host\smp;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\custom\custs\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\device_config;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\hogp\hogpd\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\spota\spotar;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\streamdata\streamdatad;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\streamdata\streamdatah;.\..\..\..\..\..\SDK_585\sdk\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\SDK_585\sdk\ble_stack\rwble;.\..\..\..\..\..\SDK_585\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\SDK_585\sdk\common_project_files;.\..\..\..\..\..\SDK_585\sdk\platform\arch;.\..\..\..\..\..\SDK_585\sdk\platform\arch\boot\rvds;.\..\..\..\..\..\SDK_585\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\SDK_585\sdk\platform\arch\ll\rvds;.\..\..\..\..\..\SDK_585\sdk\platform\arch\main;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\common\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\crypto;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\SDK_585\sdk\platform\core_modules\wlan_coex;.\..\..\..\..\..\SDK_585\sdk\platform\driver\accel;.\..\..\..\..\..\SDK_585\sdk\platform\driver\adc;.\..\..\..\..\..\SDK_585\sdk\platform\driver\battery;.\..\..\..\..\..\SDK_585\sdk\platform\driver\ble;.\..\..\..\..\..\SDK_585\sdk\platform\driver\bme280;.\..\..\..\..\..\SDK_585\sdk\platform\driver\coex;.\..\..\..\..\..\SDK_585\sdk\platform\driver\dma;.\..\..\..\..\..\SDK_585\sdk\platform\driver\emi;.\..\..\..\..\..\SDK_585\sdk\platform\driver\gpio;.\..\..\..\..\..\SDK_585\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\SDK_585\sdk\platform\driver\i2c_core;.\..\..\..\..\..\SDK_585\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\SDK_585\sdk\platform\driver\intc;.\..\..\..\..\..\SDK_585\sdk\platform\driver\inv;.\..\..\..\..\..\SDK_585\sdk\platform\driver\led;.\..\..\..\..\..\SDK_585\sdk\platform\driver\mc3410;.\..\..\..\..\..\SDK_585\sdk\platform\driver\pdm;.\..\..\..\..\..\SDK_585\sdk\platform\driver\rc5;.\..\..\..\..\..\SDK_585\sdk\platform\driver\reg;.\..\..\..\..\..\SDK_585\sdk\platform\driver\sensor;.\..\..\..\..\..\SDK_585\sdk\platform\driver\spi;.\..\..\..\..\..\SDK_585\sdk\platform\driver\spi_439;.\..\..\..\..\..\SDK_585\sdk\platform\driver\spi_flash;.\..\..\..\..\..\SDK_585\sdk\platform\driver\spi_hci;.\..\..\..\..\..\SDK_585\sdk\platform\driver\syscntl;.\..\..\..\..\..\SDK_585\sdk\platform\driver\systick;.\..\..\..\..\..\SDK_585\sdk\platform\driver\timer;.\..\..\..\..\..\SDK_585\sdk\platform\driver\trng;.\..\..\..\..\..\SDK_585\sdk\platform\driver\uart;.\..\..\..\..\..\SDK_585\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\SDK_585\sdk\platform\include;.\..\..\..\..\..\SDK_585\sdk\platform\system_library\include;..\src;..\src\config\variants\ProDK;..\src\config;..\src\drivers;..\src\platform;..\src\platform\audio;..\src\profiles\dlg_audio_svc;..\src\profiles\hogpd;..\..\..\..\..\modules_library\app_audio;..\..\..\..\..\modules_library\app_con_fsm;..\..\..\..\..\modules_library\app_dbg;..\..\..\..\..\modules_library\app_flash;..\..\..\..\..\modules_library\app_gpio_keys;..\..\..\..\..\modules_library\app_kbd;..\..\..\..\..\modules_library\app_hid_report;..\..\..\..\..\modules_library\app_leds;..\..\..\..\..\modules_library\app_motion;..\..\..\..\..\modules_library\app_mouse;..\..\..\..\..\modules_library\app_nv_prom;..\..\..\..\..\modules_library\app_ir;..\..\..\..\..\modules_library\app_stream;..\..\..\..\..\modules_library\app_touch;..\..\..\..\..\modules_library\app_touchpad;..\..\..\..\..\modules_library\port_58x;..\..\..\..\..\modules_library\port_58x\con_fsm;..\..\..\..\..\modules_library\port_58x\port_585\audio;..\..\src;..\..\src\drivers;..\..\src\platform;..\..\src\platform\con_fsm;..\..\src\drivers\AzoteqIQS572_driver;..\..\src\drivers\BMI160_driver;..\..\src\drivers\IQS263_driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: as above
  link misc: --feedback "out_585_ProDK\rcu_585_ProDK.fed" .\..\..\..\..\..\SDK_585\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=rcu_585_symdef.txt --any_placement=best_fit --datacompressor off
